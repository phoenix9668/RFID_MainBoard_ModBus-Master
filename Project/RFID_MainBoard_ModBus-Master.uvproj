# Keil uVision project RFID_MainBoard_ModBus-Master.uvproj, settings and files
target RFID_MainBoard (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: RFID_MainBoard +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\User\ioLibrary_Driver-master\Ethernet\W5500;..\User\ioLibrary_Driver-master\Internet\DHCP;..\User\ioLibrary_Driver-master\Internet\DNS;..\User\ioLibrary_Driver-master\Ethernet;..\User\ioLibrary_Driver-master\spi;..\User\ioLibrary_Driver-master\Application\loopback;..\User\Modbus_Master
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_gpio.c
  group USER
    ../User/: main.c stm32f4xx_it.c
    ../User/tim/: bsp_basic_tim.c
    ../User/function/: function.c
    ../User/usart/: bsp_com_usart.c
    ../User/gprs/: bsp_gprs.c
  group Modbus
    ../User/Modbus_Master/: modbus_master.c ringbuffer.c trans_recieve_buff_control.c
